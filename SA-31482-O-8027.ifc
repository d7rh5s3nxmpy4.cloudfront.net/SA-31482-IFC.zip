Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-09-05T13:41:07
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: SA-31482-O-8027
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: SA-31482-O-8027; Light output ratio: 1; Luminous flux: 1600 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 1600 lm; LightEmitterNominalPower: 20 W; Spectrum: 380: 17195, 385: 16992, 390: 16474, 395: 18391, 400: 19207, 405: 21723, 410: 2553, 415: 30889, 420: 40508, 425: 60127, 430: 88698, 435: 131307, 440: 213001, 445: 296898, 450: 347039, 455: 314562, 460: 253326, 465: 203246, 470: 176487, 475: 162076, 480: 167885, 485: 184594, 490: 217876, 495: 252921, 500: 296668, 505: 33177, 510: 368705, 515: 393931, 520: 419817, 525: 440992, 530: 467287, 535: 493123, 540: 516817, 545: 548343, 550: 57682, 555: 61347, 560: 653502, 565: 690102, 570: 736966, 575: 777733, 580: 828862, 585: 87775, 590: 921735, 595: 953708, 600: 981597, 605: 997181, 610: 998963, 615: 989601, 620: 96513, 625: 931099, 630: 884569, 635: 834916, 640: 778741, 645: 718889, 650: 65622, 655: 596894, 660: 538785, 665: 483489, 670: 432394, 675: 383483, 680: 341038, 685: 300876, 690: 273311, 695: 239548, 700: 207701, 705: 180901, 710: 159091, 715: 13826, 720: 120396, 725: 106475, 730: 96151, 735: 889, 740: 8534, 745: 81688, 750: 77131, 755: 70979, 760: 63169, 765: 57691, 770: 59356, 775: 62666, 780: 0; ColorTemperature: 2700 K; ColorRenderingIndex: 80

# IfcFlowTerminal: SANDY 2 Surface facade luminaires
In: Default Building
Type - Description: - Lamp LED - CRI Ra > 80 - MacAdam Ellipse 3 SDCM - Colour TW(2700 - 6500K) - Die-cast aluminium housing and frame - Pre-treated before powder coating ensuring high corrosion resistance - Two cable entries for through wiring - Stainless steel fasteners in grade 304 with zinc flake coating (ZFC) - Durable silicone rubber gasket - Opal UV-stabilised polycarbonate diffuser - Optional surface mounting box for easy wiring or conduit connection when wiring from behind is not possible; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: SANDY, Surface mounter luminaires; Housing color: Not specified
General Information - Article number: SA-31482-O-8027; Article name: SANDY 2 Surface facade luminaires; Weight: 2.1 kg; Case height: 10.5 cm; Case diameter: 20.6 cm; Uld creation date: 09.05.2022 00:00:00
Mounting Information - Mounting height: 200 cm; Recessed depth: 0 cm
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 20 W
Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 20 W; LightFixtureMountingType: WallMounted; LightFixturePlacingType: Wall; ManufacturersSpecificInformation: LIGMAN
